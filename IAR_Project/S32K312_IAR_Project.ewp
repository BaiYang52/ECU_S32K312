# IAR project S32K312_IAR_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: S32K312 NXP S32K312
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: S32K312; S32K3XX; _ICCARM_; _AR_C_S32K3XX_; DISABLE_MCAL_INTERMODULE_ASR_CHECK
  ICCARM.CCIncludePath2: BSW; BSW\Config; BSW\Config\BSW_Config; BSW\Config\BSW_Config\Include; BSW\Config\BSW_Config\src; BSW\Config\MCAL_Config; BSW\Config\MCAL_Config\Include; BSW\Config\MCAL_Config\src; BSW\MCAL; BSW\MCAL\BaseNXP_TS_T40D34M40I0R0; BSW\MCAL\BaseNXP_TS_T40D34M40I0R0\header; BSW\MCAL\BaseNXP_TS_T40D34M40I0R0\include; BSW\MCAL\BaseNXP_TS_T40D34M40I0R0\src; BSW\MCAL\Mcl_TS_T40D34M40I0R0; BSW\MCAL\Mcl_TS_T40D34M40I0R0\include; BSW\MCAL\Mcl_TS_T40D34M40I0R0\src; BSW\MCAL\Mcu_TS_T40D34M40I0R0; BSW\MCAL\Mcu_TS_T40D34M40I0R0\include; BSW\MCAL\Mcu_TS_T40D34M40I0R0\src; BSW\MCAL\Platform_TS_T40D34M40I0R0; BSW\MCAL\Platform_TS_T40D34M40I0R0\build_files; BSW\MCAL\Platform_TS_T40D34M40I0R0\build_files\iar; BSW\MCAL\Platform_TS_T40D34M40I0R0\include; BSW\MCAL\Platform_TS_T40D34M40I0R0\src; BSW\MCAL\Platform_TS_T40D34M40I0R0\startup; BSW\MCAL\Platform_TS_T40D34M40I0R0\startup\include; BSW\MCAL\Platform_TS_T40D34M40I0R0\startup\src; BSW\MCAL\Platform_TS_T40D34M40I0R0\startup\src\m7; BSW\MCAL\Platform_TS_T40D34M40I0R0\startup\src\m7\iar
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: S32K312_IAR_Project.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: BSW\MCAL\Platform_TS_T40D34M40I0R0\build_files\iar\linker_flash_s32k312.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group BSW/Config/MCAL_Config/Include
    BSW/Config/MCAL_Config/Include/: Cache_Ip_Cfg_Defines.h Cache_Ip_Cfg_DeviceRegisters.h CDD_Mcl_Cfg.h CDD_Mcl_Cfg_Defines.h CDD_Mcl_PBcfg.h Clock_Ip_Cfg.h Clock_Ip_Cfg_Defines.h Clock_Ip_PBcfg.h Dma_Ip_Cfg.h Dma_Ip_Cfg_Defines.h Dma_Ip_Cfg_DeviceRegistersV3.h Dma_Ip_Cfg_Devices.h Dma_Ip_PBcfg.h Emios_Mcl_Ip_Cfg.h Emios_Mcl_Ip_Cfg_Defines.h Emios_Mcl_Ip_Cfg_DeviceRegisters.h Emios_Mcl_Ip_PBcfg.h Flexio_Mcl_Ip_Cfg.h Flexio_Mcl_Ip_Cfg_Defines.h Flexio_Mcl_Ip_Cfg_DeviceRegisters.h Flexio_Mcl_Ip_PBcfg.h IntCtrl_Ip_Cfg.h IntCtrl_Ip_CfgDefines.h Intm_Ip_Cfg.h Intm_Ip_CfgDefines.h Lcu_Ip_Cfg.h Lcu_Ip_Cfg_Defines.h Lcu_Ip_Features.h Lcu_Ip_PBcfg.h Lcu_Ip_Regs.h Mcu_Cfg.h Mcu_Ipw_Cfg_Defines.h Mcu_PBcfg.h modules.h Mpu_M7_Ip_Cfg.h Mpu_M7_Ip_Cfg_Defines.h OsIf_ArchCfg.h OsIf_Cfg.h Platform_Cfg.h Platform_CfgDefines.h Platform_Ipw_Cfg.h Power_Ip_Cfg.h Power_Ip_Cfg_Defines.h Power_Ip_PBcfg.h Ram_Ip_Cfg.h Ram_Ip_Cfg_Defines.h Ram_Ip_PBcfg.h Soc_Ips.h System_Ip_Cfg.h System_Ip_CfgDefines.h Trgmux_Ip_Cfg.h Trgmux_Ip_Cfg_Defines.h Trgmux_Ip_Cfg_DeviceRegisters.h Trgmux_Ip_PBcfg.h
  group BSW/Config/MCAL_Config/src
    BSW/Config/MCAL_Config/src/: CDD_Mcl_Cfg.c CDD_Mcl_PBcfg.c Clock_Ip_Cfg.c Clock_Ip_PBcfg.c Dma_Ip_Cfg.c Dma_Ip_PBcfg.c Emios_Mcl_Ip_PBcfg.c Flexio_Mcl_Ip_PBcfg.c IntCtrl_Ip_Cfg.c Lcu_Ip_Cfg.c Lcu_Ip_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Mpu_M7_Ip_Cfg.c OsIf_Cfg.c Platform_Cfg.c Platform_Ipw_Cfg.c Power_Ip_Cfg.c Power_Ip_PBcfg.c Ram_Ip_Cfg.c Ram_Ip_PBcfg.c Trgmux_Ip_Cfg.c Trgmux_Ip_PBcfg.c
  group BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/header
    BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/header/: S32K312.h S32K312_ADC.h S32K312_BCTU.h S32K312_CMU_FC.h S32K312_CMU_FM.h S32K312_COMMON.h S32K312_CONFIGURATION_GPR.h S32K312_CRC.h S32K312_DCM.h S32K312_DCM_GPR.h S32K312_DMA.h S32K312_DMA_TCD.h S32K312_DMAMUX.h S32K312_EIM.h S32K312_EMIOS.h S32K312_ERM.h S32K312_FCCU.h S32K312_FIRC.h S32K312_FLASH.h S32K312_FLEXCAN.h S32K312_FLEXIO.h S32K312_FXOSC.h S32K312_INTM.h S32K312_JDC.h S32K312_LCU.h S32K312_LPCMP.h S32K312_LPI2C.h S32K312_LPSPI.h S32K312_LPUART.h S32K312_MC_CGM.h S32K312_MC_ME.h S32K312_MC_RGM.h S32K312_MCM_CM7.h S32K312_MDM_AP.h S32K312_MPU.h S32K312_MSCM.h S32K312_MU.h S32K312_NVIC.h S32K312_PFLASH.h S32K312_PIT.h S32K312_PLL.h S32K312_PMC.h S32K312_PRAMC.h S32K312_RTC.h S32K312_SCB.h S32K312_SDA_AP.h S32K312_SIRC.h S32K312_SIUL2.h S32K312_STCU.h S32K312_STM.h S32K312_SWT.h S32K312_SXOSC.h S32K312_SYSTICK.h S32K312_TEMPSENSE.h S32K312_TRGMUX.h S32K312_TSPC.h S32K312_VIRT_WRAPPER.h S32K312_WKPU.h S32K312_XBIC.h S32K312_XRDC.h
  group BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/include
    BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/include/: Adc_MemMap.h Ae_MemMap.h BaseNXP_MemMap.h BasicTypes.h Bcc_775a_MemMap.h Can_43_FLEXCAN_MemMap.h Can_43_LLCE_MemMap.h Can_GeneralTypes.h Can_MemMap.h CanIf_MemMap.h CanTrcv_43_AE_MemMap.h CanTrcv_43_fs23_MemMap.h CanTrcv_43_fs65_MemMap.h CanTrcv_43_genIO_MemMap.h CanTrcv_43_genIO_secure_MemMap.h Compiler.h Compiler_Cfg.h CompilerDefinition.h ComStack_Cfg.h ComStack_Types.h ComStackTypes.h Crc_MemMap.h Crypto_43_ACE_MemMap.h Crypto_43_HSE_MemMap.h Crypto_MemMap.h Csec_MemMap.h Dem_MemMap.h Det_MemMap.h Devassert.h Dio_MemMap.h Dpga_MemMap.h Ecum_MemMap.h Eep_MemMap.h Eth_43_GMAC_MemMap.h Eth_43_PFE_MemMap.h Eth_GeneralTypes.h Eth_MemMap.h EthSwitch_43_SJA1105P_MemMap.h EthSwt_43_SJA11XX_MemMap.h EthTrcv_43_PHY_MemMap.h EthTrcv_43_TJA110X_MemMap.h Etpu_MemMap.h Fee_MemMap.h Fls_MemMap.h Fr_43_LLCE_MemMap.h Fr_GeneralTypes.h Fr_MemMap.h Gd3162_MemMap.h Gdu_MemMap.h Gpt_MemMap.h I2c_MemMap.h I2s_MemMap.h Icu_MemMap.h Ipcf_MemMap.h IpVersionMacros.h Iseled_MemMap.h Lin_43_LLCE_MemMap.h Lin_43_LPUART_FLEXIO_MemMap.h Lin_GeneralTypes.h Lin_MemMap.h LinTrcv_43_AE_MemMap.h LinTrcv_43_fs23_MemMap.h LinTrcv_43_fs65_MemMap.h Mcal.h Mcem_MemMap.h Mcl_MemMap.h Mcu_MemMap.h Mem_43_EEP_MemMap.h Mem_43_EXFLS_MemMap.h Mem_43_INFLS_MemMap.h MemAcc_GeneralTypes.h MemAcc_MemMap.h MotorControl_MemMap.h Ocotp_MemMap.h Ocu_MemMap.h OsIf.h OsIf_Cfg_TypesDef.h OsIf_DeviceRegisters.h OsIf_Internal.h OsIf_Interrupts.h OsIf_Timer_Custom.h OsIf_Timer_System.h OsIf_Timer_System_Internal_Systick.h Platform_MemMap.h Platform_Types.h PlatformTypes.h Pmic_MemMap.h Port_MemMap.h Pwm_MemMap.h RdcChecker_MemMap.h Reg_eSys.h RegLockMacros.h Rm_MemMap.h Rte_MemMap.h Sbc_fs23_MemMap.h Sbc_fs26_MemMap.h Sbc_fs65_MemMap.h Sbc_fs8x_MemMap.h Sent_MemMap.h Spi_MemMap.h StandardTypes.h Std_Types.h Uart_MemMap.h Wdg_43_fs23_MemMap.h Wdg_43_fs26_MemMap.h Wdg_43_fs65_MemMap.h Wdg_43_fs8x_MemMap.h Wdg_MemMap.h Zipwire_MemMap.h
  group BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/src
    BSW/MCAL/BaseNXP_TS_T40D34M40I0R0/src/: OsIf_Interrupts.c OsIf_Timer.c OsIf_Timer_System.c OsIf_Timer_System_Internal_Systick.c
  group BSW/MCAL/Mcl_TS_T40D34M40I0R0/include
    BSW/MCAL/Mcl_TS_T40D34M40I0R0/include/: Cache_Ip.h Cache_Ip_Devassert.h Cache_Ip_HwAcc_ArmCoreMx.h Cache_Ip_TrustedFunctions.h Cache_Ip_Types.h CDD_Mcl.h CDD_Mcl_Ipw.h CDD_Mcl_Irq.h Dma_Ip.h Dma_Ip_Devassert.h Dma_Ip_Driver_State.h Dma_Ip_Hw_Access.h Dma_Ip_Hwv3_AccessInline.h Dma_Ip_Irq.h Dma_Ip_Multicore.h Dma_Ip_TrustedFunctions.h Dma_Ip_Types.h Emios_Mcl_Ip.h Emios_Mcl_Ip_Irq.h Emios_Mcl_Ip_Types.h Flexio_Mcl_Ip.h Flexio_Mcl_Ip_HwAccess.h Flexio_Mcl_Ip_Types.h Lcu_Ip.h Lcu_Ip_Devassert.h Lcu_Ip_Hw_Access.h Lcu_Ip_Irq.h Lcu_Ip_Multicore.h Lcu_Ip_Types.h Mcl.h Mcl_TrustedFunctions.h Mcl_Types.h Trgmux_Ip.h Trgmux_Ip_Devassert.h Trgmux_Ip_HwAcc.h Trgmux_Ip_TrustedFunctions.h Trgmux_Ip_Types.h
  group BSW/MCAL/Mcl_TS_T40D34M40I0R0/src
    BSW/MCAL/Mcl_TS_T40D34M40I0R0/src/: Cache_Ip.c Cache_Ip_HwAcc_ArmCoreMx.c CDD_Mcl.c CDD_Mcl_Ipw.c Dma_Ip.c Dma_Ip_Driver_State.c Dma_Ip_Hw_Access.c Dma_Ip_Irq.c Dma_Ip_Multicore.c Emios_Mcl_Ip.c Emios_Mcl_Ip_Irq.c Flexio_Mcl_Ip.c Flexio_Mcl_Ip_HwAccess.c Flexio_Mcl_Ip_Irq.c Lcu_Ip.c Lcu_Ip_Hw_Access.c Lcu_Ip_Irq.c Lcu_Ip_Multicore.c Trgmux_Ip.c Trgmux_Ip_HwAcc.c
  group BSW/MCAL/Mcu_TS_T40D34M40I0R0/include
    BSW/MCAL/Mcu_TS_T40D34M40I0R0/include/: Clock_Ip.h Clock_Ip_Derivative_001.h Clock_Ip_Derivative_002.h Clock_Ip_Derivative_003.h Clock_Ip_Derivative_004.h Clock_Ip_Derivative_005.h Clock_Ip_Derivative_006.h Clock_Ip_Derivative_007.h Clock_Ip_Derivative_008.h Clock_Ip_Derivative_009.h Clock_Ip_Private.h Clock_Ip_Specific.h Clock_Ip_TrustedFunctions.h Clock_Ip_Types.h Mcu.h Mcu_Dem_Wrapper.h Mcu_EnvCfg.h Mcu_Ipw.h Mcu_Ipw_Types.h Mcu_TrustedFunctions.h Power_Ip.h Power_Ip_AEC.h Power_Ip_AEC_Types.h Power_Ip_CortexM7.h Power_Ip_DCM_GPR.h Power_Ip_DCM_GPR_Types.h Power_Ip_FLASH.h Power_Ip_MC_ME.h Power_Ip_MC_ME_Types.h Power_Ip_MC_RGM.h Power_Ip_MC_RGM_Types.h Power_Ip_PMC.h Power_Ip_PMC_Types.h Power_Ip_Private.h Power_Ip_Specific.h Power_Ip_TrustedFunctions.h Power_Ip_Types.h Ram_Ip.h Ram_Ip_Types.h
  group BSW/MCAL/Mcu_TS_T40D34M40I0R0/src
    BSW/MCAL/Mcu_TS_T40D34M40I0R0/src/: Clock_Ip.c Clock_Ip_Data.c Clock_Ip_Divider.c Clock_Ip_DividerTrigger.c Clock_Ip_ExtOsc.c Clock_Ip_FracDiv.c Clock_Ip_Frequency.c Clock_Ip_Gate.c Clock_Ip_IntOsc.c Clock_Ip_Irq.c Clock_Ip_Monitor.c Clock_Ip_Pll.c Clock_Ip_ProgFreqSwitch.c Clock_Ip_Selector.c Clock_Ip_Specific.c Mcu.c Mcu_Dem_Wrapper.c Mcu_Ipw.c Power_Ip.c Power_Ip_AEC.c Power_Ip_CortexM7.c Power_Ip_DCM_GPR.c Power_Ip_FLASH.c Power_Ip_MC_ME.c Power_Ip_MC_RGM.c Power_Ip_MC_RGM_Irq.c Power_Ip_PMC.c Power_Ip_PMC_Irq.c Power_Ip_Private.c Ram_Ip.c
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/include
    BSW/MCAL/Platform_TS_T40D34M40I0R0/include/: IntCtrl_Ip.h IntCtrl_Ip_TrustedFunctions.h IntCtrl_Ip_TypesDef.h Intm_Ip.h Mpu_M7_Ip.h Mpu_M7_Ip_TrustedFunctions.h Mpu_M7_Ip_Types.h Platform.h Platform_Ipw.h Platform_Ipw_TypesDef.h Platform_TypesDef.h System_Ip.h
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/src
    BSW/MCAL/Platform_TS_T40D34M40I0R0/src/: IntCtrl_Ip.c Mpu_M7_Ip.c Platform.c Platform_Ipw.c System_Ip.c
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/include
    BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/include/: core_specific.h nvic.h sys_init.h system.h
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src
    BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src/: nvic.c sys_init.c system.c
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src/m7
    BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src/m7/: exceptions.c startup.c
  group BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src/m7/iar
    BSW/MCAL/Platform_TS_T40D34M40I0R0/startup/src/m7/iar/: startup_cm7.s Vector_Table.s
